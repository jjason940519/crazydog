Commit message: add joint pose control

File: crazydog_ws/src/lqr_control/lqr_control/robot_models/big bipedal robot v1/urdf/big bipedal robot v1.urdf (robot description, URDF)
Before this commit: robot big bipedal robot v1, 10 links, 9 joints
Links:
- link hipR_link: mass None -> 0.575
